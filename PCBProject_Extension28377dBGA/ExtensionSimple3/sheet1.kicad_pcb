# Repository horychen/ProjectEureka

File readme.md:

# ProjectEureka!--A Multi-phase Motor Drive Design for Robot or Maglev systems

ProjectEureka seeks to streamline the intricate design of robot systems, including communication, cable arrangements, and synchronization, by integrating several motor drivers (up to four) with a single microcontroller (DSP2837xD). This can also be utilized as a testing platform for bearingless motor or any other kind of AC motors. For access to example codes, please visit the following link: [here](https://github.com/horychen/ProjectPanGu-C) for cpu01 code, and [here](https://github.com/horychen/ProjectPanGuCpu2) for cpu02 code. Displayed below is an image representing the previous version.

## Software

We have been shifting from Altium Designer to KiCAD.

## Characteristics

**Multi-board modulized design is adopted in Project Eureka!.** Project Eureka! includes:

1. Current sensor(LA55-P) [📂 PCBProject_SensorLEM](PCBProject_SensorLEM)
2. DAC data collect board(MAX5725)[📂PCBProject_SPI_MAX5307_DAC](PCBProject_SPI_MAX5307_DAC)
3. RS422/RS423 communication board [📂PCBProject_Encoder](PCBProject_Encoder)
4. Inverters (FNC42060F) [📂PCBProject_InverterFNC42060F](PCBProject_InverterFNC42060F)
5. Auxiliary power supply [📂PCBProject_Power](PCBProject_Power)
6. Mother board that connected all the boards above [📂PCBProject_Extension28377dBGA](PCBProject_Extension28377dBGA)
7. CAN/SCI/USB communication board[📂PCBProject_Can_SCI_USB](PCBProject_Can_SCI_USB)
8. RS485 communication board [📂PCBProject_Happy485](PCBProject_Happy485)

This means:

1. Convenient alternative for replacing one's own projects or addressing shortages of components.
2. Utilize a single board design in their own design.
3. Quick update and easy for collaboration (KiCAD 8 supports git now).

**ProjectEureka can drive at most four AC motors.** Thanks to the TMS320F28377D from TI, ProjectEureka can drive at most four AC motors by adding necessary inverter blocks and corresponding current sensors, which means:

1. Facilitates communication and synchronization among motors.
2. Suitable for organizing cables in a user-friendly manner.

## Liscence
GPLv3

## Other Similar Projects

Odrive and VESC are two famous projects that support the control of a three-phase motor.
There are inverter designs that are compatible with them, see e.g., [Axiom](https://hackaday.io/project/164932-axiom-100kw-motor-controller). Other similar but less known hardwares can also be found, see e.g., [moteus-c1](https://jpieper.com/2024/04/30/moteus-c1/). Yet another project I recently found is [STMBL](https://github.com/rene-dev/stmbl?tab=readme-ov-file) for STM32 microprocessor.

ProjectEureka! is, however, focusing on the more advanced topic of a complicated system that requires extendable hardwares.
In this sense, there is indeed one similar purpose project that is based on Xilinx, i.e., [the AMDC platform from the group of Prof. Eric L. Severson](https://amdc.dev/). See also [its doc](https://docs.amdc.dev/getting-started/user-guide/host-interface/index.html) and [its blog post](https://severson.wempec.wisc.edu/2022/02/11/introducing-the-advanced-motor-drive-controller/).

As a comparison, ProjectEureka! currently only supports 28379D that has one CLB module of a very limited FPGA capability.

## KiCad design PCBProject_Extension28377dBGA/ExtensionSimple3/sheet1.kicad_pcb

Board: 4 copper layers, 140.3 x 101.7 mm, 125 parts (100 on the bottom side), 121 nets.

Parts:
ANALOGINPUT1, ANALOGINPUT2: TP-黄色测试点; TestPoint_Pad_2.0x2.0mm
C1, C2, C3, C4, C9: 104; C_0805_2012Metric
C5, C6, C7, C8, C13, C14, C16, C17: 102; C_0805_2012Metric
C10, C11, C12, C15, C18: 103; C_0805_2012Metric
CAN_A1: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
CAN_B1: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
CLB_BiSS_C1: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
D1, D2, D4, D5: BAR43S; SOT-23
D3: LEDRED; LED_0805_2012Metric
DI1: Conn_02x02_Counter_Clockwise; PinSocket_2x02_P2.54mm_Vertical
DSP1: TMS320F28377D-BGA-P1A; DSP_240_P1A
DSP2: TMS320F28377D-BGA-P1B; DSP_240_P1B
DSP3: TMS320F28377D-BGA-P1C; DSP_240_P1C
ECAP1, ECAP2: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
IPM1, IPM2: Conn_02x08_Top_Bottom; PinSocket_2x08_P2.54mm_Vertical
J1: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical
J2, J3, J4, J5: Conn_01x02_Pin; PinSocket_2x02_P2.54mm_Vertical
J6: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
LEM1, LEM2: HIF3FC-30PA-2.54DSA; PinSocket_2x15_P2.54mm_Vertical
N1: MCP6024; SOIC14_M
POWER1: HIF3FC-30PA-2.54DSA; PinSocket_2x15_P2.54mm_Vertical
Q1: FMMT618TA; SOT-23
R1, R2, R3, R4, R7, R8, R9, R10, R11, R12: 4.7k; R_0805_2012Metric
R5, R6: 4.7K; R_0805_2012Metric
R13, R14, R15, R16: 0R; R_0805_2012Metric
R17, R18, R19, R20, R27, R28, R29, R32, R33, R34, R35, R36, R37, R39, R40, R41, R42, R44, R45: 10K; R_0805_2012Metric
R21, R22, R24, R31, R38, R43: 1K; R_0805_2012Metric
R23: 100R; R_0805_2012Metric
R25: 1.69K/1%; R_0805_2012Metric
R26: 3.3K/1%; R_0805_2012Metric
R30: 2K; R_0805_2012Metric
RU1, RU2: DNP; R_0805_2012Metric
RU3, RU5: 0R; R_0805_2012Metric
SPI3: Conn_02x04_Counter_Clockwise; PinSocket_2x04_P2.54mm_Vertical
SPI-DAC2: HIF3FC-20PA-2.54DSA; SHDR20W56P254_2X10_3290X850X950P
TESTPOINT1, TESTPOINT2, TESTPOINT3, TESTPOINT4, TESTPOINT5, TESTPOINT6, TESTPOINT7: TP-黄色测试点; TestPoint_Pad_2.0x2.0mm
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12: TP-黄色测试点; TestPoint_Pad_2.0x2.0mm
U1, U2: SN74ABT541; TSSOP-20
UART1, UART2, UART3, UART4: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
VDC_BUS1, VDC_BUS2: TP-黄色测试点; TestPoint_Pad_2.0x2.0mm

Connections:
12VGND: IPM1.13, IPM1.15, IPM2.13, IPM2.15, LEM1.19, LEM1.20, LEM1.21, LEM1.22, LEM2.19, LEM2.20, LEM2.21, LEM2.22, POWER1.9, POWER1.10, POWER1.11, POWER1.12, RU3.2
+12: LEM1.27, LEM1.28, LEM2.27, LEM2.28, POWER1.1, POWER1.2, POWER1.3, POWER1.4
-12: LEM1.29, LEM1.30, LEM2.29, LEM2.30, POWER1.5, POWER1.6, POWER1.7, POWER1.8
/ANALOGINPUT1: ANALOGINPUT1.1, C18.2, D5.3, DSP3.172 (ADD0_172), R43.2
/ANALOGINPUT2: ANALOGINPUT2.1, C15.2, D4.3, DSP3.176 (ADC2_176), R38.2
/BootFromFlash: DSP2.119 (119_GP84), R25.1, R26.2
/CLB_DATA_IN: CLB_BiSS_C1.2, DSP1.25 (25_GP24)
/CLB_DATA_OUT: CLB_BiSS_C1.3, DSP1.26 (GP25_26)
/CLB_PWR_CTL: CLB_BiSS_C1.4, DSP1.66 (GP32_66)
/CLB_SPICLK: CLB_BiSS_C1.5, DSP1.27 (27_GP26), DSP1.38 (GP7_38)
/CLB_TX_DIR: CLB_BiSS_C1.1, DSP2.124 (CS2_124)
/DC_BUS_2M1: J2.1, J2.3, R14.2
/DC_BUS_2M2: J3.1, J3.3, R16.2
/DI-1-DSP-3.3V: C12.2, DSP2.95 (95_D9), R23.1, R24.1
/DSP-PWM1A: DSP3.193 (193_PWM1A), R1.2, U1.3 (A2)
/DSP-PWM1B: DSP3.195 (195_PWM1B), R7.2, U1.6 (A5)
/DSP-PWM2A: DSP3.197 (197_PWM2A), R3.2, U1.4 (A3)
/DSP-PWM2B: DSP3.199 (199_PWM2B), R9.2, U1.7 (A6)
/DSP-PWM3A: DSP3.201 (201_PWM3A), R5.2, U1.5 (A4)
/DSP-PWM3B: DSP3.203 (203_PWM3B), R11.2, U1.8 (A7)
/DSP-PWM4A: DSP3.205 (205_PWM4A), R2.2, U2.3 (A2)
/DSP-PWM4B: DSP3.207 (207_PWM4B), R8.2, U2.6 (A5)
/DSP-PWM5A: DSP3.209 (209_PWM5A), R4.2, U2.4 (A3)
/DSP-PWM5B: DSP3.211 (211_PWM5B), R10.2, U2.7 (A6)
/DSP-PWM6A: DSP3.213 (213_PWM6A), R6.2, U2.5 (A4)
/DSP-PWM6B: DSP3.215 (215_PWM6B), R12.2, U2.8 (A7)
/DSP_A_CAN_RX: CAN_A1.4, DSP1.18 (GP62_18), TESTPOINT6.1
/DSP_A_CAN_TX: CAN_A1.5, DSP1.17 (17_GP19), TESTPOINT7.1
/DSP_B_CAN_RX: CAN_B1.4, DSP1.34 (GP21_34)
/DSP_B_CAN_TX: CAN_B1.5, DSP1.33 (33_GP20)
/DSP_PWM1~_ENABLE: C1.2, DSP2.153 (153_GP108), R27.1, U1.1 (*OE1), U1.19 (*OE2)
/DSP_PWM2~_ENABLE: C2.2, DSP2.155 (155_GP93), R28.1, U2.1 (*OE1), U2.19 (*OE2)
/DSP_PWM3~_ENABLE: DSP2.154 (GP28_154), R32.2
/DSP_PWM4~_ENABLE: DSP2.156 (GP29_156), R33.2
/ECAP1_IPM_TerminalDutyU1: DSP2.84 (A19_84), ECAP1.1
/ECAP2_IPM_TerminalDutyV1: DSP2.86 (A18_86), ECAP1.2
/ECAP3_IPM_TerminalDutyW1: DSP2.88 (A17_88), ECAP1.3
/ECAP4_IPM_TerminalDutyU2: DSP2.90 (A16_90), ECAP2.1
/ECAP5_IPM_TerminalDutyV2: DSP2.92 (A15_92), ECAP2.2
/ECAP6_IPM_TerminalDutyW2: DSP2.94 (A14_94), ECAP2.3
/GND_2M1: J2.2, J2.4, R13.2
/GND_2M2: J3.2, J3.4, R15.2
/IPM_IU1: DSP3.187 (187_ADA1), LEM2.5, LEM2.6
/IPM_IU2: DSP3.181 (181_ADB1), LEM1.5, LEM1.6
/IPM_IV1: DSP3.186 (ADA2_186), LEM2.3, LEM2.4
/IPM_IV2: DSP3.180 (ADB2_180), LEM1.3, LEM1.4
/IPM_IW1: DSP3.185 (185_ADA3), LEM2.1, LEM2.2
/IPM_IW2: DSP3.179 (179_ADB3), LEM1.1, LEM1.2
/IPM_VDC_BUS1: C10.2, D1.3, DSP3.188 (ADA0_188), R21.2, VDC_BUS1.1
/IPM_VDC_BUS2: C11.2, D2.3, DSP3.182 (ADB0_182), R22.2, VDC_BUS2.1
/LED1: DSP1.11 (11_GP3), R29.2
/MQEP1A: DSP1.21 (21_GP96), J1.2
/MQEP1B: DSP1.22 (GP97_22), J1.4
/MQEP1Z: DSP1.24 (GP99_24), J1.6
/MSCLA: DSP2.149 (149_GP1), J6.5, J6.6
/MSDAA: DSP2.150 (GP0_150), J6.7, J6.8
/PWM1A_5V: IPM1.2, TP11.1, U1.17 (Y2)
/PWM1B_5V: IPM1.8, TP5.1, U1.14 (Y5)
/PWM2A_5V: IPM1.4, TP9.1, U1.16 (Y3)
/PWM2B_5V: IPM1.10, TP3.1, U1.13 (Y6)
/PWM3A_5V: IPM1.6, TP7.1, U1.15 (Y4)
/PWM3B_5V: IPM1.12, TP1.1, U1.12 (Y7)
/PWM4A_5V: IPM2.2, TP12.1, U2.17 (Y2)
/PWM4B_5V: IPM2.8, TP6.1, U2.14 (Y5)
/PWM5A_5V: IPM2.4, TP10.1, U2.16 (Y3)
/PWM5B_5V: IPM2.10, TP4.1, U2.13 (Y6)
/PWM6A_5V: IPM2.6, TP8.1, U2.15 (Y4)
/PWM6B_5V: IPM2.12, TP2.1, U2.12 (Y7)
/QEP1_HALL_U: DSP1.62 (GP68_62), J1.1
/QEP1_HALL_V: DSP1.60 (GP94_60), J1.3
/QEP1_HALL_W: DSP1.58 (GP17_58), J1.5
/SPI_A_CK_HS: DSP1.44 (GP60_44), SPI3.4
/SPI_A_MI_HS: DSP1.77 (77_GP59), SPI3.2
/SPI_A_MO_HS: DSP1.75 (75_GP58), SPI3.1
/SPI_C_CK_HS: DSP2.87 (87_D13), SPI-DAC2.2, TESTPOINT4.1
/SPI_C_MI_HS: DSP2.85 (85_D14), SPI-DAC2.4
/SPI_C_MO_HS: DSP2.83 (83_D15), SPI-DAC2.1
/UART_SCI_RXDA: DSP2.129 (129_GP136), TESTPOINT1.1, UART1.4
/UART_SCI_RXDB: DSP2.127 (127_GP138), UART2.4
/UART_SCI_RXDC: DSP2.120 (A1_120), UART3.4
/UART_SCI_RXDD: DSP2.110 (A6_110), UART4.4
/UART_SCI_TXDA: DSP2.131 (131_GP135), TESTPOINT2.1, UART1.6
/UART_SCI_TXDB: DSP2.117 (117_GP137), UART2.6
/UART_SCI_TXDC: DSP2.122 (A0_122), UART3.6
/UART_SCI_TXDD: DSP2.108 (A7_108), UART4.6
/UART_SCI_WRA: DSP2.125 (125_RD), TESTPOINT5.1, UART1.5
/UART_SCI_WRB: DSP2.123 (123_WE), UART2.5
/UART_SCI_WRC: DSP2.109 (109_D2), UART3.5
/UART_SCI_WRD: DSP2.111 (111_D1), UART4.5
/~SPI_A_STE_HS: DSP1.43 (43_GP61), SPI3.3
/~SPI_C_STE_HS: DSP2.89 (89_D12), SPI-DAC2.3
A+5V: C9.2, ECAP1.4, ECAP2.4, LEM1.23, LEM1.24, LEM2.23, LEM2.24, N1.4, POWER1.21, POWER1.22, POWER1.23, POWER1.24, POWER1.25, POWER1.26, R44.1, R45.1, SPI-DAC2.11, SPI-DAC2.12
A-5V: LEM1.25, LEM1.26, LEM2.25, LEM2.26, POWER1.13, POWER1.14, SPI-DAC2.9, SPI-DAC2.10
AGND: C1.1, C2.1, C3.2, C4.2, C5.1, C6.1, C9.1, C10.1, C11.1, C12.1, C13.1, C15.1, C16.1, C18.1, CAN_A1.3, CAN_B1.3, D1.1, D2.1, D4.1, D5.1, DI1.2, DSP1.7 (7_GND), DSP1.8 (GND_8), DSP1.9 (9_GND), DSP1.10 (GND10), DSP1.28 (GP27_28), DSP2.157 (157_GND), DSP2.158 (GND_158), DSP2.159 (159_GND), DSP2.160 (GND_160), DSP3.161 (161_GND), DSP3.162 (GND_162), DSP3.163 (163_GND), DSP3.164 (GND_164), DSP3.189 (189_GND), DSP3.190 (GND_190), DSP3.191 (191_GND), DSP3.192 (GND_192), DSP3.217 (217_GND), DSP3.218 (GND_218), DSP3.219 (219_GND), DSP3.220 (GND_220), ECAP1.6, ECAP2.6, IPM1.1, IPM1.3, IPM1.5, IPM1.7, IPM1.9, IPM1.11, IPM2.1, IPM2.3, IPM2.5, IPM2.7, IPM2.9, IPM2.11, J1.9, J4.1, J4.3, J5.1, J5.3, J6.3, J6.4, J6.9, J6.10, LEM1.8, LEM1.9, LEM1.10, LEM1.11, LEM1.12, LEM1.13, LEM1.14, LEM1.15, LEM1.16, LEM1.17, LEM1.18, LEM2.8, LEM2.9, LEM2.10, LEM2.11, LEM2.12, LEM2.13, LEM2.14, LEM2.15, LEM2.16, LEM2.17, LEM2.18, N1.11, POWER1.15, POWER1.16, POWER1.17, POWER1.18, Q1.2 (E), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R17.1, R18.1, R24.2, R26.1, R30.2, R35.2, R36.1, R40.2, R41.1, RU3.1, SPI3.5, SPI3.6, SPI-DAC2.5, SPI-DAC2.6, SPI-DAC2.7, SPI-DAC2.8, TESTPOINT3.1, U1.10 (GND), U2.10 (GND), UART1.3, UART2.3, UART3.3, UART4.3
AVDD: D1.2, D2.2, D4.2, D5.2, POWER1.28
D12V1: CAN_A1.1, CAN_B1.1, IPM1.14, IPM1.16, IPM2.14, IPM2.16, POWER1.19, POWER1.20
D+5V: C3.1, C4.1, CAN_A1.2, CAN_B1.2, D3.1 (A), DSP1.1 (1_+5V), DSP1.2 (+5V_2), DSP1.3 (3_+5V), DSP1.4 (+5V_4), DSP1.5 (5_+5V), DSP1.6 (+5V_6), DSP2.81 (81+5V), DSP2.82 (+5V_82), J1.10, POWER1.29, POWER1.30, R25.2, SPI3.7, SPI3.8, SPI-DAC2.13, SPI-DAC2.14, U1.20 (VCC), U2.20 (VCC), UART1.1, UART2.1, UART3.1, UART4.1
unnamed: C5.2, N1.3, R14.1, R17.2
unnamed: C6.2, N1.5, R16.1, R18.2
unnamed: C7.1, N1.2, R13.1, R19.1
unnamed: C7.2, N1.1, R19.2, R21.1
unnamed: C8.1, N1.6, R15.1, R20.1
unnamed: C8.2, N1.7, R20.2, R22.1
unnamed: C13.2, N1.12, R35.1, R36.2
unnamed: C14.1, N1.13, R34.1, R37.1
unnamed: C14.2, N1.14, R37.2, R38.1
unnamed: C16.2, N1.10, R40.1, R41.2
unnamed: C17.1, N1.9, R39.1, R42.1
unnamed: C17.2, N1.8, R42.2, R43.1
unnamed: D3.2 (K), R31.2
unnamed: DI1.3, DI1.4, R23.2
unnamed: J4.2, J4.4, R34.2, R44.2
unnamed: J5.2, J5.4, R39.2, R45.2
unnamed: LEM1.7, RU1.2
unnamed: LEM2.7, RU2.2
unnamed: Q1.1 (B), R29.1, R30.1
unnamed: Q1.3 (C), R31.1
unnamed: RU5.2, SPI-DAC2.19, SPI-DAC2.20
PE_GND: J1.7, SPI-DAC2.15, SPI-DAC2.16, SPI-DAC2.17, SPI-DAC2.18
REF_3V: RU2.1, RU5.1
VDD: DI1.1, ECAP1.5, ECAP2.5, J1.8, J6.1, J6.2, POWER1.27, R27.2, R28.2, R32.1, R33.1, UART1.2, UART2.2, UART3.2, UART4.2

## KiCad design PCBProject_ADC_Extension/ADC_Extension/ADC_Extension.kicad_pcb

Parts:
J1: Conn_01x20; PinHeader_1x20_P2.54mm_Vertical
J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical

Connections:
/ADA4: J1.14; also elsewhere on the board
/ADA5: J1.13; also elsewhere on the board
/ADB4: J1.12; also elsewhere on the board
/ADB5: J1.11; also elsewhere on the board
/ADC3: J1.10; also elsewhere on the board
/ADC4: J1.9; also elsewhere on the board
/ADC5: J1.8; also elsewhere on the board
/ADD1: J1.7; also elsewhere on the board
/ADD2: J1.5; also elsewhere on the board
/ADD3: J1.6; also elsewhere on the board
/ADD4: J1.3; also elsewhere on the board
/ADD5: J1.4; also elsewhere on the board
/AD_14: J1.1; also elsewhere on the board
/AD_15: J1.2; also elsewhere on the board
/IN+_1: J2.2; also elsewhere on the board
/IN+_2: J3.2; also elsewhere on the board
/IN+_3: J4.2; also elsewhere on the board
/IN+_4: J5.2; also elsewhere on the board
/IN+_5: J6.2; also elsewhere on the board
/IN+_6: J7.2; also elsewhere on the board
/IN+_7: J8.2; also elsewhere on the board
/IN+_8: J9.2; also elsewhere on the board
/IN+_9: J10.2; also elsewhere on the board
/IN+_10: J11.2; also elsewhere on the board
/IN+_11: J12.2; also elsewhere on the board
/IN+_12: J13.2; also elsewhere on the board
/IN+_13: J14.2; also elsewhere on the board
/IN+_14: J15.2; also elsewhere on the board
/IN-_1: J2.1; also elsewhere on the board
/IN-_2: J3.1; also elsewhere on the board
/IN-_3: J4.1; also elsewhere on the board
/IN-_4: J5.1; also elsewhere on the board
/IN-_5: J6.1; also elsewhere on the board
/IN-_6: J7.1; also elsewhere on the board
/IN-_7: J8.1; also elsewhere on the board
/IN-_8: J9.1; also elsewhere on the board
/IN-_9: J10.1; also elsewhere on the board
/IN-_10: J11.1; also elsewhere on the board
/IN-_11: J12.1; also elsewhere on the board
/IN-_12: J13.1; also elsewhere on the board
/IN-_13: J14.1; also elsewhere on the board
/IN-_14: J15.1; also elsewhere on the board
A+5V: J1.18; also elsewhere on the board
AGND: J1.20; also elsewhere on the board
AVDD: J1.19; also elsewhere on the board

Notes on the sheet:
ADC拓展

Parts:
ANALOGINPUT1, ANALOGINPUT2, ANALOGINPUT3, ANALOGINPUT4: TP-黄色测试点; TestPoint_Pad_2.0x2.0mm; MANUFACTURER PART TP-黄色测试点; LCSC PART NAME TP-黄色测试点
C1, C2, C3, C4, C5, C6, C7, C8, C12, C13, C14, C15, C16, C17, C18, C19: 102; C_0805_2012Metric
C9: 104; C_0805_2012Metric
C10, C11, C20, C21: 103; C_0805_2012Metric
D1, D2, D3, D4: BAR43S; SOT-23
N1: MCP6024; SOIC14_M
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34: 10K; R_0805_2012Metric
R17, R18, R35, R36: 1K; R_0805_2012Metric

Connections:
/ADD4: ANALOGINPUT3.1, C21.2, D4.3, R36.2; also elsewhere on the board
/ADD5: ANALOGINPUT4.1, C20.2, D3.3, R35.2; also elsewhere on the board
/AD_14: ANALOGINPUT1.1, C10.2, D1.3, R17.2; also elsewhere on the board
/AD_15: ANALOGINPUT2.1, C11.2, D2.3, R18.2; also elsewhere on the board
/IN+_1: R6.2; also elsewhere on the board
/IN+_2: R5.2; also elsewhere on the board
/IN+_3: R23.2; also elsewhere on the board
/IN+_4: R24.2; also elsewhere on the board
/IN-_1: R2.2; also elsewhere on the board
/IN-_2: R1.2; also elsewhere on the board
/IN-_3: R19.2; also elsewhere on the board
/IN-_4: R20.2; also elsewhere on the board
A+5V: C9.2, N1.4; also elsewhere on the board
AGND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C20.1, C21.1, D1.1, D2.1, D3.1, D4.1, N1.11, R3.1, R4.1, R7.1, R8.1, R13.1, R14.1, R21.1, R22.1, R25.1, R26.1, R31.1, R32.1; also elsewhere on the board
AVDD: D1.2, D2.2, D3.2, D4.2; also elsewhere on the board
unnamed: C1.2, R1.1, R3.2, R12.2
unnamed: C2.2, R2.1, R4.2, R10.2
unnamed: C3.2, R5.1, R7.2, R11.2
unnamed: C4.2, R6.1, R8.2, R9.2
unnamed: C5.2, N1.3, R9.1, R13.2
unnamed: C6.2, N1.5, R11.1, R14.2
unnamed: C7.1, N1.2, R10.1, R15.1
unnamed: C7.2, N1.1, R15.2, R17.1
unnamed: C8.1, N1.6, R12.1, R16.1
unnamed: C8.2, N1.7, R16.2, R18.1
unnamed: C12.2, R19.1, R21.2, R30.2
unnamed: C13.2, R20.1, R22.2, R27.2
unnamed: C14.2, R23.1, R25.2, R29.2
unnamed: C15.2, R24.1, R26.2, R28.2
unnamed: C16.2, N1.12, R28.1, R31.2
unnamed: C17.2, N1.10, R29.1, R32.2
unnamed: C18.1, N1.13, R27.1, R33.1
unnamed: C18.2, N1.14, R33.2, R35.1
unnamed: C19.1, N1.9, R30.1, R34.1
unnamed: C19.2, N1.8, R34.2, R36.1

Parts of its further copies:
ANALOGINPUT5, ANALOGINPUT6, ANALOGINPUT7, ANALOGINPUT8, ANALOGINPUT9, ANALOGINPUT10, ANALOGINPUT11, ANALOGINPUT12, ANALOGINPUT13, ANALOGINPUT14, ANALOGINPUT15, ANALOGINPUT16: TP-黄色测试点; TestPoint_Pad_2.0x2.0mm; MANUFACTURER PART TP-黄色测试点; LCSC PART NAME TP-黄色测试点
C22, C23, C24, C25, C26, C27, C28, C29, C33, C34, C35, C36, C37, C38, C39, C40, C43, C44, C45, C46, C47, C48, C49, C50, C54, C55, C56, C57, C58, C59, C60, C61, C64, C65, C66, C67, C68, C69, C70, C71, C75, C76, C77, C78, C79, C80, C81, C82: 102; C_0805_2012Metric
C30, C51, C72: 104; C_0805_2012Metric
C31, C32, C41, C42, C52, C53, C62, C63, C73, C74, C83, C84: 103; C_0805_2012Metric
D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: BAR43S; SOT-23
N2, N3, N4: MCP6024; SOIC14_M
R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R73, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R87, R88, R91, R92, R93, R94, R95, R96, R97, R98, R99, R100, R101, R102, R103, R104, R105, R106, R109, R110, R111, R112, R113, R114, R115, R116, R117, R118, R119, R120, R121, R122, R123, R124, R127, R128, R129, R130, R131, R132, R133, R134, R135, R136, R137, R138, R139, R140, R141, R142: 10K; R_0805_2012Metric
R53, R54, R71, R72, R89, R90, R107, R108, R125, R126, R143, R144: 1K; R_0805_2012Metric

Connections of its further copies:
/ADA4: ANALOGINPUT14.1, C74.2, D14.3, R126.2; also elsewhere on the board
/ADA5: ANALOGINPUT13.1, C73.2, D13.3, R125.2; also elsewhere on the board
/ADB4: ANALOGINPUT11.1, C62.2, D11.3, R107.2; also elsewhere on the board
/ADB5: ANALOGINPUT12.1, C63.2, D12.3, R108.2; also elsewhere on the board
/ADC3: ANALOGINPUT10.1, C53.2, D10.3, R90.2; also elsewhere on the board
/ADC4: ANALOGINPUT9.1, C52.2, D9.3, R89.2; also elsewhere on the board
/ADC5: ANALOGINPUT8.1, C41.2, D7.3, R71.2; also elsewhere on the board
/ADD1: ANALOGINPUT7.1, C42.2, D8.3, R72.2; also elsewhere on the board
/ADD2: ANALOGINPUT5.1, C31.2, D5.3, R53.2; also elsewhere on the board
/ADD3: ANALOGINPUT6.1, C32.2, D6.3, R54.2; also elsewhere on the board
/FourChannelMCP6024_4/ADC_3: ANALOGINPUT15.1, C84.2, D16.3, R144.2
/FourChannelMCP6024_4/ADC_4: ANALOGINPUT16.1, C83.2, D15.3, R143.2
/FourChannelMCP6024_4/IN+_3: R131.2
/FourChannelMCP6024_4/IN+_4: R132.2
/FourChannelMCP6024_4/IN-_3: R127.2
/FourChannelMCP6024_4/IN-_4: R128.2
/IN+_5: R42.2; also elsewhere on the board
/IN+_6: R41.2; also elsewhere on the board
/IN+_7: R59.2; also elsewhere on the board
/IN+_8: R60.2; also elsewhere on the board
/IN+_9: R78.2; also elsewhere on the board
/IN+_10: R77.2; also elsewhere on the board
/IN+_11: R95.2; also elsewhere on the board
/IN+_12: R96.2; also elsewhere on the board
/IN+_13: R114.2; also elsewhere on the board
/IN+_14: R113.2; also elsewhere on the board
/IN-_5: R38.2; also elsewhere on the board
/IN-_6: R37.2; also elsewhere on the board
/IN-_7: R55.2; also elsewhere on the board
/IN-_8: R56.2; also elsewhere on the board
/IN-_9: R74.2; also elsewhere on the board
/IN-_10: R73.2; also elsewhere on the board
/IN-_11: R91.2; also elsewhere on the board
/IN-_12: R92.2; also elsewhere on the board
/IN-_13: R110.2; also elsewhere on the board
/IN-_14: R109.2; also elsewhere on the board
A+5V: C30.2, C51.2, C72.2, N2.4, N3.4, N4.4; also elsewhere on the board
AGND: C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C62.1, C63.1, C64.1, C65.1, C66.1, C67.1, C68.1, C69.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.1, C78.1, C79.1, C80.1, C83.1, C84.1, D5.1, D6.1, D7.1, D8.1, D9.1, D10.1, D11.1, D12.1, D13.1, D14.1, D15.1, D16.1, N2.11, N3.11, N4.11, R39.1, R40.1, R43.1, R44.1, R49.1, R50.1, R57.1, R58.1, R61.1, R62.1, R67.1, R68.1, R75.1, R76.1, R79.1, R80.1, R85.1, R86.1, R93.1, R94.1, R97.1, R98.1, R103.1, R104.1, R111.1, R112.1, R115.1, R116.1, R121.1, R122.1, R129.1, R130.1, R133.1, R134.1, R139.1, R140.1; also elsewhere on the board
AVDD: D5.2, D6.2, D7.2, D8.2, D9.2, D10.2, D11.2, D12.2, D13.2, D14.2, D15.2, D16.2; also elsewhere on the board
unnamed: C22.2, R37.1, R39.2, R48.2
unnamed: C23.2, R38.1, R40.2, R46.2
unnamed: C24.2, R41.1, R43.2, R47.2
unnamed: C25.2, R42.1, R44.2, R45.2
unnamed: C26.2, N2.3, R45.1, R49.2
unnamed: C27.2, N2.5, R47.1, R50.2
unnamed: C28.1, N2.2, R46.1, R51.1
unnamed: C28.2, N2.1, R51.2, R53.1
unnamed: C29.1, N2.6, R48.1, R52.1
unnamed: C29.2, N2.7, R52.2, R54.1
unnamed: C33.2, R55.1, R57.2, R66.2
unnamed: C34.2, R56.1, R58.2, R63.2
unnamed: C35.2, R59.1, R61.2, R65.2
unnamed: C36.2, R60.1, R62.2, R64.2
unnamed: C37.2, N2.12, R64.1, R67.2
unnamed: C38.2, N2.10, R65.1, R68.2
unnamed: C39.1, N2.13, R63.1, R69.1
unnamed: C39.2, N2.14, R69.2, R71.1
unnamed: C40.1, N2.9, R66.1, R70.1
unnamed: C40.2, N2.8, R70.2, R72.1
unnamed: C43.2, R73.1, R75.2, R84.2
unnamed: C44.2, R74.1, R76.2, R82.2
unnamed: C45.2, R77.1, R79.2, R83.2
unnamed: C46.2, R78.1, R80.2, R81.2
unnamed: C47.2, N3.3, R81.1, R85.2
unnamed: C48.2, N3.5, R83.1, R86.2
unnamed: C49.1, N3.2, R82.1, R87.1
unnamed: C49.2, N3.1, R87.2, R89.1
unnamed: C50.1, N3.6, R84.1, R88.1
unnamed: C50.2, N3.7, R88.2, R90.1
unnamed: C54.2, R91.1, R93.2, R102.2
unnamed: C55.2, R92.1, R94.2, R99.2
unnamed: C56.2, R95.1, R97.2, R101.2
unnamed: C57.2, R96.1, R98.2, R100.2
unnamed: C58.2, N3.12, R100.1, R103.2
unnamed: C59.2, N3.10, R101.1, R104.2
unnamed: C60.1, N3.13, R99.1, R105.1
unnamed: C60.2, N3.14, R105.2, R107.1
unnamed: C61.1, N3.9, R102.1, R106.1
unnamed: C61.2, N3.8, R106.2, R108.1
unnamed: C64.2, R109.1, R111.2, R120.2
unnamed: C65.2, R110.1, R112.2, R118.2
unnamed: C66.2, R113.1, R115.2, R119.2
unnamed: C67.2, R114.1, R116.2, R117.2
unnamed: C68.2, N4.3, R117.1, R121.2
unnamed: C69.2, N4.5, R119.1, R122.2
unnamed: C70.1, N4.2, R118.1, R123.1
unnamed: C70.2, N4.1, R123.2, R125.1
unnamed: C71.1, N4.6, R120.1, R124.1
unnamed: C71.2, N4.7, R124.2, R126.1
unnamed: C75.2, R127.1, R129.2, R138.2
unnamed: C76.2, R128.1, R130.2, R135.2
unnamed: C77.2, R131.1, R133.2, R137.2
unnamed: C78.2, R132.1, R134.2, R136.2
unnamed: C79.2, N4.12, R136.1, R139.2
unnamed: C80.2, N4.10, R137.1, R140.2
unnamed: C81.1, N4.13, R135.1, R141.1
unnamed: C81.2, N4.14, R141.2, R143.1
unnamed: C82.1, N4.9, R138.1, R142.1
unnamed: C82.2, N4.8, R142.2, R144.1

Notes on the sheet:
VDC 300V-1.5V

Board: 4 copper layers, 113.6 x 74.8 mm, 279 parts (0 on the bottom side), 127 nets.
