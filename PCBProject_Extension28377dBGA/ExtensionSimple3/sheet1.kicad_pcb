# Repository horychen/ProjectEureka (continued)

## KiCad design PCBProject_SPI_MAX5307_DAC/pcb5/pcb5.kicad_pcb

Parts:
BNC1, BNC2, BNC3, BNC4, BNC5, BNC6, BNC7, BNC8: BNC; CPBNCPC010; Manufacturer_Part_Number CP-BNCPC-010; Mouser Part Number 530-CPBNCPC-010
C1, C2, C3, C5: 101; C_0603_1608Metric
C4, C22, C28: 104; C_0603_1608Metric
C6, C7, C8, C9, C10, C11, C12, C13, C23, C24, C26, C27, C29, C30, C31, C32: 102; C_0603_1608Metric
C14, C16, C18, C19: 103; C_0603_1608Metric
C15, C17, C20, C21: 105; C_0603_1608Metric
C25: 4.7uF; C_0603_1608Metric
C33, C35: 104; C_0805_2012Metric
C34, C36: 106 25V; C_1206_3216Metric
C37, C38: 10uF; C_0805_2012Metric
C39: 0.1uF; C_0805_2012Metric
IC1: MAX5725BAUP+; SOP65P640X110-20N; Manufacturer_Part_Number MAX5725BAUP+; Mouser Part Number 700-MAX5725BAUP+
R1, R2, R3, R4, R5, R6, R7, R8: 0R; R_0603_1608Metric
R9, R10, R11, R12, R15, R16, R17, R18, R23, R24, R25, R26, R29, R30, R31, R32: 10k; R_0603_1608Metric
R13, R14, R19, R21, R27, R28, R33, R34: 510; R_0603_1608Metric
R20: 1k; R_0603_1608Metric
R22: 5k; R_0603_1608Metric
SPI-DAC1: HIF3FC-20PA-2.54DSA; SHDR20W56P254_2X10_3290X850X950P; MANUFACTURER_PART_NUMBER HIF3FC-20PA-2.54DSA(71); MOUSER PART NUMBER 798-HIF3FC20PA254D71
U1: SN74HC365D; SOIC127P600X175-16N
U2, U3: LM224DR; SOIC127P600X175-14N
U4: ADR423ARZ; SOIC127P600X175-8N; MANUFACTURER_PART_NUMBER ADR423ARZ
U5: LM2662M_NOPB; SOIC127P600X175-8N; Manufacturer_Part_Number LM2662M/NOPB; Mouser Part Number 926-LM2662M/NOPB

Connections:
-5V: C14.1, C15.2, C16.1, C17.2, C38.2, C39.2, U2.11, U3.11, U5.5 (OUT)
/DACA: BNC1.1, C32.1, R34.2
/DACB: BNC2.1, C29.1, R27.2
/DACC: BNC3.1, C27.1, R21.2
/DACD: BNC4.1, C23.1, R13.2
/DACE: BNC5.1, C26.1, R19.2
/DACF: BNC6.1, C24.1, R14.2
/DACG: BNC7.1, C31.1, R33.2
/DACH: BNC8.1, C30.1, R28.2
/SPICLKA_5V: IC1.14 (SCLK), U1.5 (2Y)
/SPISIMOA_5V: IC1.13 (DIN), U1.3 (1Y)
/SPISOMIA_5V: IC1.12 (DOUT), U1.9 (4Y)
/SPI_CK_HS: C2.1, SPI-DAC1.2, U1.4 (2A)
/SPI_MI_HS: C5.1, SPI-DAC1.4, U1.10 (4A)
/SPI_MO_HS: C1.1, SPI-DAC1.1, U1.2 (1A)
/VOUTA: IC1.2 (OUT0), U2.12
/VOUTB: IC1.3 (OUT1), U2.10
/VOUTC: IC1.4 (OUT2), U2.5
/VOUTD: IC1.5 (OUT3), U2.3
/VOUTE: IC1.6 (OUT4), U3.5
/VOUTF: IC1.7 (OUT5), U3.3
/VOUTG: IC1.8 (OUT6), U3.12
/VOUTH: IC1.9 (OUT7), U3.10
/~SPISTEA_5V: IC1.15 (CSB), U1.7 (3Y)
/~SPI_STE_HS: C3.1, SPI-DAC1.3, U1.6 (3A)
D+5V: C4.1, C18.1, C19.1, C20.2, C21.2, C22.2, C25.2, C28.2, C33.2, C34.1, IC1.10 (VDD), IC1.11 (VDDIO), IC1.18 (~LDAC), IC1.20 (M/~Z), R20.2, R22.2, SPI-DAC1.11, SPI-DAC1.12, SPI-DAC1.13, SPI-DAC1.14, U1.16 (VCC), U2.4, U3.4, U4.2 (VIN), U5.8 (V+)
GNDREF: C1.2, C2.2, C3.2, C4.2, C5.2, C14.2, C15.1, C16.2, C17.1, C18.2, C19.2, C20.1, C21.1, C22.1, C23.2, C24.2, C25.1, C26.2, C27.2, C28.1, C29.2, C30.2, C31.2, C32.2, C33.1, C34.2, C35.1, C36.2, C38.1, C39.1, IC1.19 (GND), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, SPI-DAC1.5, SPI-DAC1.6, SPI-DAC1.7, SPI-DAC1.8, U1.1 (~OE1), U1.8 (GND), U1.15 (~OE2), U4.4 (GND), U5.3 (GND), U5.6 (LV)
unnamed: BNC1.2, R1.2
unnamed: BNC1.MH1, BNC1.MH2, C6.1
unnamed: BNC2.2, R3.2
unnamed: BNC2.MH1, BNC2.MH2, C8.1
unnamed: BNC3.2, R5.2
unnamed: BNC3.MH1, BNC3.MH2, C10.1
unnamed: BNC4.2, R7.2
unnamed: BNC4.MH1, BNC4.MH2, C12.1
unnamed: BNC5.2, R2.2
unnamed: BNC5.MH1, BNC5.MH2, C7.1
unnamed: BNC6.2, R4.2
unnamed: BNC6.MH1, BNC6.MH2, C9.1
unnamed: BNC7.2, R6.2
unnamed: BNC7.MH1, BNC7.MH2, C11.1
unnamed: BNC8.2, R8.2
unnamed: BNC8.MH1, BNC8.MH2, C13.1
unnamed: IC1.17 (~CLR), R20.1
unnamed: IC1.16 (~IRQ), R22.1
unnamed: R10.2, R12.1, U3.2
unnamed: R9.2, R11.1, U2.2
unnamed: R11.2, R13.1, U2.1
unnamed: R12.2, R14.1, U3.1
unnamed: R15.2, R17.1, U3.6
unnamed: R16.2, R18.1, U2.6
unnamed: R17.2, R19.1, U3.7
unnamed: R18.2, R21.1, U2.7
unnamed: R23.2, R25.1, U2.9
unnamed: R24.2, R26.1, U3.9
unnamed: R25.2, R27.1, U2.8
unnamed: R26.2, R28.1, U3.8
unnamed: R29.2, R31.1, U3.13
unnamed: R30.2, R32.1, U2.13
unnamed: R31.2, R33.1, U3.14
unnamed: R32.2, R34.1, U2.14
unnamed: C37.2, U5.2 (CAP+)
unnamed: C37.1, U5.4 (CAP-)
PE_GND: C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, SPI-DAC1.17, SPI-DAC1.18, SPI-DAC1.19, SPI-DAC1.20
REF_3V: C35.2, C36.1, IC1.1 (REF), R9.1, R10.1, R15.1, R16.1, R23.1, R24.1, R29.1, R30.1, U4.6 (VOUT)

Notes on the sheet:
增加的元器件
DAC
8路DAC-Bipolar

Board: 4 copper layers, 93.9 x 51.7 mm, 88 parts (8 on the bottom side), 65 nets.

## KiCad design PCBProject_Extension28377dBGA/ExtensionSimple4/sheet1.kicad_pcb

Board: 4 copper layers, 153.2 x 142.2 mm, 353 parts (237 on the bottom side), 238 nets.

Parts:
A1, A2, A3, A4, A5, A6, A7, A8, A9, A10, A11, A12: LTC6240HV; SOT95P280X100-5N
C1, C2, C3, C4, C5, C6, C8, C9, C14, C23, C36: 104; C_0805_2012Metric
C7, C15, C16, C21, C22, C28, C29, C30, C31, C32, C33, C41, C43, C44, C48, C49, C50, C51, C52, C53, C60, C61, C62, C66, C67, C68, C69, C70, C71, C78, C79, C80, C84, C85, C86, C87, C88, C89, C96, C97, C98, C99, C100, C101: 103; C_0805_2012Metric
C10, C11, C12, C13, C17, C18, C19, C20: 102; C_0805_2012Metric
C24, C26, C27, C45, C46, C47, C63, C64, C65, C81, C82, C83: 101; C_0805_2012Metric
C25, C42: 106 25V; 1206 (钽电容)
C34, C35, C37, C38, C39, C40, C54, C55, C56, C57, C58, C59, C72, C73, C74, C75, C76, C77, C90, C91, C92, C93, C94, C95: 105; C_0805_2012Metric
CAN_A1: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
CAN_B1: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
CLB_BiSS_C1: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
D1: LEDRED; LED_0805_2012Metric
D2, D3, D4, D5: BAR43S; SOT-23
DC_BUS_2M3, DC_BUS_2M4: TP-黄色测试点; TestPoint_Pad_1.0x1.0mm
DI1, DI2, DI3, DI4: Conn_02x02_Counter_Clockwise; PinSocket_2x02_P2.54mm_Vertical
DSP1: TMS320F28377D-BGA-P1B; DSP_240_P1B
DSP2: TMS320F28377D-BGA-P1C; DSP_240_P1C
DSP3: TMS320F28377D-BGA-P1A; DSP_240_P1A
ECAP1, ECAP2: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
GND_2M3, GND_2M4: TP-黄色测试点; TestPoint_Pad_1.0x1.0mm
I2C1, I2C2: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
IPM-LEM1, IPM-LEM2, IPM-LEM3, IPM-LEM4: HIF3FC-20PA-2.54DSA; SHDR20W56P254_2X10_3290X850X950P
J1, J2, J3, J4: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical
N1: MCP6024; SOIC14_M
POWER1: HIF3FC-30PA-2.54DSA; PinSocket_2x15_P2.54mm_Vertical
Q1: FMMT618TA; SOT-23
R1, R2, R3, R5, R6, R8, R9, R10, R11, R12, R16, R17, R18, R19, R22, R23, R24, R25, R26, R27: 4.7k; R_0805_2012Metric
R4, R7, R20, R21: 4.7K; R_0805_2012Metric
R13, R32, R33, R34, R35, R40, R41, R42, R43, R50, R51, R52, R53: 10K; R_0805_2012Metric
R14: 2K; R_0805_2012Metric
R15, R29, R44, R45, R54, R55, R117, R119, R121: 1K; R_0805_2012Metric
R28, R116, R118, R120: 100R; R_0805_2012Metric
R30: 1.69K/1%; R_0805_2012Metric
R31: 3.3K/1%; R_0805_2012Metric
R36, R37, R38, R39, R46, R47, R48, R49: 0R; R_0805_2012Metric
R56, R58, R60, R62, R64, R66, R71, R73, R75, R77, R79, R81, R86, R88, R90, R92, R94, R96, R101, R103, R105, R107, R109, R111: 20k; R_0805_2012Metric
R57, R59, R61, R63, R65, R67, R72, R74, R76, R78, R80, R82, R87, R89, R91, R93, R95, R97, R102, R104, R106, R108, R110, R112: 10k; R_0805_2012Metric
R68, R69, R70, R83, R84, R85, R98, R99, R100, R113, R114, R115: 470R; R_0805_2012Metric
RB1, RB2, RB3, RB4, RB5, RB6, RB7, RB8, RB9, RB10, RB11, RB12: 0R; R_0805_2012Metric
RM1, RM2, RM3, RM4, RM5, RM6, RM7, RM8, RM9, RM10, RM11, RM12: 24R 1%精度; R_2512_6332Metric
RU1, RU2: 0R; R_0805_2012Metric
RU7, RU8, RU9, RU10, RU11, RU12, RU13, RU14, RU15, RU16, RU17, RU18: DNP; R_0805_2012Metric
SPI1, SPI2: Conn_02x04_Counter_Clockwise; PinSocket_2x04_P2.54mm_Vertical
SPI-DAC1: HIF3FC-20PA-2.54DSA; SHDR20W56P254_2X10_3290X850X950P
TESTPOINT1, TESTPOINT2, TESTPOINT3, TESTPOINT4, TESTPOINT5, TESTPOINT6, TESTPOINT7: TP-黄色测试点; TestPoint_Pad_1.0x1.0mm
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24: TP-黄色测试点; TestPoint_Pad_1.0x1.0mm
U1, U2, U3, U4: SN74ABT541; TSSOP-20
U5: ADR423ARZ; SOIC-8
UART1, UART2, UART3, UART4: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
VDC_BUS1, VDC_BUS2, VDC_BUS3, VDC_BUS4: TP-黄色测试点; TestPoint_Pad_1.0x1.0mm

Connections:
12VGND: IPM-LEM1.13, IPM-LEM1.15, IPM-LEM2.13, IPM-LEM2.15, IPM-LEM3.13, IPM-LEM3.15, IPM-LEM4.13, IPM-LEM4.15, POWER1.9, POWER1.10, POWER1.11, POWER1.12, R58.1, R62.1, R66.1, R73.1, R77.1, R81.1, R88.1, R92.1, R96.1, R103.1, R107.1, R111.1, RM1.2, RM2.2, RM3.2, RM4.2, RM5.2, RM6.2, RM7.2, RM8.2, RM9.2, RM10.2, RM11.2, RM12.2, RU1.2
+12: IPM-LEM1.18, IPM-LEM2.18, IPM-LEM3.18, IPM-LEM4.18, POWER1.1, POWER1.2, POWER1.3, POWER1.4
-12: IPM-LEM1.17, IPM-LEM2.17, IPM-LEM3.17, IPM-LEM4.17, POWER1.5, POWER1.6, POWER1.7, POWER1.8
/BootFromFlash: DSP1.119 (119_GP84), R30.1, R31.2
/CLB_DATA_IN: CLB_BiSS_C1.2, DSP3.25 (25_GP24)
/CLB_DATA_OUT: CLB_BiSS_C1.3, DSP3.26 (GP25_26)
/CLB_PWR_CTL: CLB_BiSS_C1.4, DSP3.66 (GP32_66)
/CLB_SPICLK: CLB_BiSS_C1.5, DSP3.27 (27_GP26), DSP3.38 (GP7_38)
/CLB_TX_DIR: CLB_BiSS_C1.1, DSP1.124 (CS2_124)
/CSO1_1: IPM-LEM1.1, R61.1, RM2.1
/CSO1_2: IPM-LEM1.3, R65.1, RM3.1
/CSO1_3: IPM-LEM1.5, R57.1, RM1.1
/CSO2_1: IPM-LEM2.1, R76.1, RM5.1
/CSO2_2: IPM-LEM2.3, R80.1, RM6.1
/CSO2_3: IPM-LEM2.5, R72.1, RM4.1
/CSO3_1: IPM-LEM3.1, R91.1, RM8.1
/CSO3_2: IPM-LEM3.3, R95.1, RM9.1
/CSO3_3: IPM-LEM3.5, R87.1, RM7.1
/CSO4_1: IPM-LEM4.1, R106.1, RM11.1
/CSO4_2: IPM-LEM4.3, R110.1, RM12.1
/CSO4_3: IPM-LEM4.5, R102.1, RM10.1
/DC_BUS_2M1: IPM-LEM1.4, R37.2
/DC_BUS_2M2: IPM-LEM2.4, R39.2
/DC_BUS_2M3: IPM-LEM3.4, R46.2
/DC_BUS_2M4: IPM-LEM4.4, R48.2
/DI-1-DSP-3.3V: C7.2, DSP1.95 (95_D9), R28.1, R29.1
/DI-2-DSP-3.3V: C101.2, DSP1.97 (97_D8), R120.1, R121.1
/DI-3-DSP-3.3V: C99.2, DSP1.91 (91_D11), R116.1, R117.1
/DI-4-DSP-3.3V: C100.2, DSP1.93 (93_D10), R118.1, R119.1
/DSP-PWM1A: DSP2.193 (193_PWM1A), R16.2, U3.3 (A2)
/DSP-PWM1B: DSP2.195 (195_PWM1B), R22.2, U3.6 (A5)
/DSP-PWM2A: DSP2.197 (197_PWM2A), R18.2, U3.4 (A3)
/DSP-PWM2B: DSP2.199 (199_PWM2B), R24.2, U3.7 (A6)
/DSP-PWM3A: DSP2.201 (201_PWM3A), R20.2, U3.5 (A4)
/DSP-PWM3B: DSP2.203 (203_PWM3B), R26.2, U3.8 (A7)
/DSP-PWM4A: DSP2.205 (205_PWM4A), R17.2, U4.3 (A2)
/DSP-PWM4B: DSP2.207 (207_PWM4B), R23.2, U4.6 (A5)
/DSP-PWM5A: DSP2.209 (209_PWM5A), R19.2, U4.4 (A3)
/DSP-PWM5B: DSP2.211 (211_PWM5B), R25.2, U4.7 (A6)
/DSP-PWM6A: DSP2.213 (213_PWM6A), R21.2, U4.5 (A4)
/DSP-PWM6B: DSP2.215 (215_PWM6B), R27.2, U4.8 (A7)
/DSP-PWM7A: DSP2.194 (PWM7A_194), R1.2, U1.3 (A2)
/DSP-PWM7B: DSP2.196 (PWM7B_196), R6.2, U1.6 (A5)
/DSP-PWM8A: DSP2.198 (PWM8A_198), R2.2, U1.4 (A3)
/DSP-PWM8B: DSP2.200 (PWM8B_200), R8.2, U1.7 (A6)
/DSP-PWM9A: DSP2.202 (PWM9A_202), R4.2, U1.5 (A4)
/DSP-PWM9B: DSP2.204 (PWM9B_204), R10.2, U1.8 (A7)
/DSP-PWM10A: DSP2.206 (PWM10A_206), R3.2, U2.3 (A2)
/DSP-PWM10B: DSP2.208 (PWM10B_208), R9.2, U2.6 (A5)
/DSP-PWM11A: DSP2.210 (PWM11A_210), R5.2, U2.4 (A3)
/DSP-PWM11B: DSP2.212 (PWM11B_212), R11.2, U2.7 (A6)
/DSP-PWM12A: DSP2.214 (PWM12A_214), R7.2, U2.5 (A4)
/DSP-PWM12B: DSP2.216 (PWM12B_216), R12.2, U2.8 (A7)
/DSP_A_CAN_RX: CAN_A1.4, DSP3.18 (GP62_18), TESTPOINT6.1
/DSP_A_CAN_TX: CAN_A1.5, DSP3.17 (17_GP19), TESTPOINT7.1
/DSP_B_CAN_RX: CAN_B1.4, DSP3.34 (GP21_34)
/DSP_B_CAN_TX: CAN_B1.5, DSP3.33 (33_GP20)
/DSP_PWM1~_ENABLE: C5.2, DSP1.153 (153_GP108), R32.1, U3.1 (*OE1), U3.19 (*OE2)
/DSP_PWM2~_ENABLE: C6.2, DSP1.155 (155_GP93), R33.1, U4.1 (*OE1), U4.19 (*OE2)
/DSP_PWM3~_ENABLE: C1.2, DSP1.154 (GP28_154), R34.2, U1.1 (*OE1), U1.19 (*OE2)
/DSP_PWM4~_ENABLE: C2.2, DSP1.156 (GP29_156), R35.2, U2.1 (*OE1), U2.19 (*OE2)
/ECAP1_IPM_TerminalDutyU1: DSP1.84 (A19_84), ECAP1.1
/ECAP2_IPM_TerminalDutyV1: DSP1.86 (A18_86), ECAP1.2
/ECAP3_IPM_TerminalDutyW1: DSP1.88 (A17_88), ECAP1.3
/ECAP4_IPM_TerminalDutyU2: DSP1.90 (A16_90), ECAP2.1
/ECAP5_IPM_TerminalDutyV2: DSP1.92 (A15_92), ECAP2.2
/ECAP6_IPM_TerminalDutyW2: DSP1.94 (A14_94), ECAP2.3
/GND_2M1: IPM-LEM1.6, R36.2
/GND_2M2: IPM-LEM2.6, R38.2
/GND_2M3: IPM-LEM3.6, R47.2
/GND_2M4: IPM-LEM4.6, R49.2
/IPM_IU1: C43.2, DSP2.187 (187_ADA1), R69.1
/IPM_IU2: C61.2, DSP2.181 (181_ADB1), R84.1
/IPM_IU3: C79.2, DSP2.171 (171_ADD1), R99.1
/IPM_IU4: C97.2, DSP2.175 (175_ADC3), R114.1
/IPM_IV1: C44.2, DSP2.186 (ADA2_186), R70.1
/IPM_IV2: C62.2, DSP2.180 (ADB2_180), R85.1
/IPM_IV3: C80.2, DSP2.170 (ADD3_170), R100.1
/IPM_IV4: C98.2, DSP2.174 (ADC4_174), R115.1
/IPM_IW1: C41.2, DSP2.185 (185_ADA3), R68.1
/IPM_IW2: C60.2, DSP2.179 (179_ADB3), R83.1
/IPM_IW3: C78.2, DSP2.169 (169_ADD2), R98.1
/IPM_IW4: C96.2, DSP2.173 (173_ADC5), R113.1
/IPM_VDC_BUS1: C15.2, D2.3, DSP2.188 (ADA0_188), R44.2, VDC_BUS1.1
/IPM_VDC_BUS2: C16.2, D3.3, DSP2.182 (ADB0_182), R45.2, VDC_BUS2.1
/IPM_VDC_BUS3: C21.2, D4.3, DSP2.172 (ADD0_172), R54.2, VDC_BUS3.1
/IPM_VDC_BUS4: C22.2, D5.3, DSP2.176 (ADC2_176), R55.2, VDC_BUS4.1
/LED1: DSP3.11 (11_GP3), R13.2
/MQEP1A: DSP3.21 (21_GP96), J1.2
/MQEP1B: DSP3.22 (GP97_22), J1.4
/MQEP1Z: DSP3.24 (GP99_24), J1.6
/MQEP2A: DSP3.53 (53_GP100), J2.2
/MQEP2B: DSP3.56 (GP101_56), J2.4
/MQEP2Z: DSP3.54 (GP103_54), J2.6
/MQEP3A: DSP3.29 (29_GP104), J3.2
/MQEP3B: DSP3.30 (GP105_30), J3.4
/MQEP3Z: DSP3.32 (GP107_32), J3.6
/MSCLA: DSP1.149 (149_GP1), I2C1.5, I2C1.6
/MSCLB: DSP1.116 (A3_116), I2C2.5, I2C2.6
/MSDAA: DSP1.150 (GP0_150), I2C1.7, I2C1.8
/MSDAB: DSP1.118 (A2_118), I2C2.7, I2C2.8
/PWM1A_5V: IPM-LEM1.7, TP23.1, U3.17 (Y2)
/PWM1B_5V: IPM-LEM1.8, TP17.1, U3.14 (Y5)
/PWM2A_5V: IPM-LEM1.9, TP21.1, U3.16 (Y3)
/PWM2B_5V: IPM-LEM1.10, TP15.1, U3.13 (Y6)
/PWM3A_5V: IPM-LEM1.11, TP19.1, U3.15 (Y4)
/PWM3B_5V: IPM-LEM1.12, TP13.1, U3.12 (Y7)
/PWM4A_5V: IPM-LEM2.7, TP24.1, U4.17 (Y2)
/PWM4B_5V: IPM-LEM2.8, TP18.1, U4.14 (Y5)
/PWM5A_5V: IPM-LEM2.9, TP22.1, U4.16 (Y3)
/PWM5B_5V: IPM-LEM2.10, TP16.1, U4.13 (Y6)
/PWM6A_5V: IPM-LEM2.11, TP20.1, U4.15 (Y4)
/PWM6B_5V: IPM-LEM2.12, TP14.1, U4.12 (Y7)
/PWM7A_5V: IPM-LEM3.7, TP11.1, U1.17 (Y2)
/PWM7B_5V: IPM-LEM3.8, TP5.1, U1.14 (Y5)
/PWM8A_5V: IPM-LEM3.9, TP9.1, U1.16 (Y3)
/PWM8B_5V: IPM-LEM3.10, TP3.1, U1.13 (Y6)
/PWM9A_5V: IPM-LEM3.11, TP7.1, U1.15 (Y4)
/PWM9B_5V: IPM-LEM3.12, TP1.1, U1.12 (Y7)
/PWM10A_5V: IPM-LEM4.7, TP12.1, U2.17 (Y2)
/PWM10B_5V: IPM-LEM4.8, TP6.1, U2.14 (Y5)
/PWM11A_5V: IPM-LEM4.9, TP10.1, U2.16 (Y3)
/PWM11B_5V: IPM-LEM4.10, TP4.1, U2.13 (Y6)
/PWM12A_5V: IPM-LEM4.11, TP8.1, U2.15 (Y4)
/PWM12B_5V: IPM-LEM4.12, TP2.1, U2.12 (Y7)
/QEP1_HALL_U: DSP3.62 (GP68_62), J1.1
/QEP1_HALL_V: DSP3.60 (GP94_60), J1.3
/QEP1_HALL_W: DSP3.58 (GP17_58), J1.5
/QEP2_HALL_U: DSP3.67 (67_GP127), J2.1
/QEP2_HALL_V: DSP3.65 (65_GP116), J2.3
/QEP2_HALL_W: DSP3.63 (63_GP131), J2.5
/QEP3_HALL_U: DSP3.70 (GP117_70), J3.1
/QEP3_HALL_V: DSP3.72 (GP130_72), J3.3
/QEP3_HALL_W: DSP3.74 (GP54_74), J3.5
/QEP4_HALL_U: DSP3.69 (69_GP128), J4.1
/QEP4_HALL_V: DSP3.71 (71_GP126), J4.3
/QEP4_HALL_W: DSP3.73 (73_GP95), J4.5
/SPI_A_CK_HS: DSP3.44 (GP60_44), SPI2.4
/SPI_A_MI_HS: DSP3.77 (77_GP59), SPI2.2
/SPI_A_MO_HS: DSP3.75 (75_GP58), SPI2.1
/SPI_B_CK_HS: DSP1.146 (GP65_146), SPI1.7
/SPI_B_MI_HS: DSP1.147 (147_GP64), SPI1.2
/SPI_B_MO_HS: DSP1.145 (145_GP63), SPI1.1
/SPI_C_CK_HS: DSP1.87 (87_D13), SPI-DAC1.2, TESTPOINT4.1
/SPI_C_MI_HS: DSP1.85 (85_D14), SPI-DAC1.4
/SPI_C_MO_HS: DSP1.83 (83_D15), SPI-DAC1.1
/UART_SCI_RXDA: DSP1.129 (129_GP136), TESTPOINT1.1, UART1.4
/UART_SCI_RXDB: DSP1.127 (127_GP138), UART2.4
/UART_SCI_RXDC: DSP1.120 (A1_120), UART3.4
/UART_SCI_RXDD: DSP1.108 (A7_108), UART4.4
/UART_SCI_TXDA: DSP1.131 (131_GP135), TESTPOINT2.1, UART1.6
/UART_SCI_TXDB: DSP1.117 (117_GP137), UART2.6
/UART_SCI_TXDC: DSP1.122 (A0_122), UART3.6
/UART_SCI_TXDD: DSP1.110 (A6_110), UART4.6
/UART_SCI_WRA: DSP1.125 (125_RD), TESTPOINT5.1, UART1.5
/UART_SCI_WRB: DSP1.123 (123_WE), UART2.5
/UART_SCI_WRC: DSP1.109 (109_D2), UART3.5
/UART_SCI_WRD: DSP1.111 (111_D1), UART4.5
/~SPI_A_STE_HS: DSP3.43 (43_GP61), SPI2.3
/~SPI_B_STE_HS: DSP1.148 (GP143_148), SPI1.8
/~SPI_C_STE_HS: DSP1.89 (89_D12), SPI-DAC1.3
A+5V: A1.5 (Vcc), A2.5 (Vcc), A3.5 (Vcc), A4.5 (Vcc), A5.5 (Vcc), A6.5 (Vcc), A7.5 (Vcc), A8.5 (Vcc), A9.5 (Vcc), A10.5 (Vcc), A11.5 (Vcc), A12.5 (Vcc), C14.2, C23.2, C25.1, C28.2, C30.2, C32.2, C34.2, C37.2, C39.2, C48.2, C50.2, C52.2, C54.2, C56.2, C58.2, C66.2, C68.2, C70.2, C72.2, C74.2, C76.2, C84.2, C86.2, C88.2, C90.2, C92.2, C94.2, ECAP1.4, ECAP2.4, N1.4, POWER1.21, POWER1.22, POWER1.23, POWER1.24, POWER1.25, POWER1.26, SPI-DAC1.11, SPI-DAC1.12, U5.2 (VIN)
A-5V: A1.2 (Vee), A2.2 (Vee), A3.2 (Vee), A4.2 (Vee), A5.2 (Vee), A6.2 (Vee), A7.2 (Vee), A8.2 (Vee), A9.2 (Vee), A10.2 (Vee), A11.2 (Vee), A12.2 (Vee), C29.2, C31.2, C33.2, C35.2, C38.2, C40.2, C49.2, C51.2, C53.2, C55.2, C57.2, C59.2, C67.2, C69.2, C71.2, C73.2, C75.2, C77.2, C85.2, C87.2, C89.2, C91.2, C93.2, C95.2, POWER1.13, POWER1.14, SPI-DAC1.9, SPI-DAC1.10
AGND: C1.1, C2.1, C3.2, C4.2, C5.1, C6.1, C7.1, C8.2, C9.2, C10.1, C11.1, C14.1, C15.1, C16.1, C17.1, C18.1, C21.1, C22.1, C23.1, C24.2, C25.2, C26.2, C27.2, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.2, C43.1, C44.1, C45.2, C46.2, C47.2, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, C63.2, C64.2, C65.2, C66.1, C67.1, C68.1, C69.1, C70.1, C71.1, C72.1, C73.1, C74.1, C75.1, C76.1, C77.1, C78.1, C79.1, C80.1, C81.2, C82.2, C83.2, C84.1, C85.1, C86.1, C87.1, C88.1, C89.1, C90.1, C91.1, C92.1, C93.1, C94.1, C95.1, C96.1, C97.1, C98.1, C99.1, C100.1, C101.1, CAN_A1.3, CAN_B1.3, D2.1, D3.1, D4.1, D5.1, DI1.2, DI2.2, DI3.2, DI4.2, DSP1.157 (157_GND), DSP1.158 (GND_158), DSP1.159 (159_GND), DSP1.160 (GND_160), DSP2.161 (161_GND), DSP2.162 (GND_162), DSP2.163 (163_GND), DSP2.164 (GND_164), DSP2.189 (189_GND), DSP2.190 (GND_190), DSP2.191 (191_GND), DSP2.192 (GND_192), DSP2.217 (217_GND), DSP2.218 (GND_218), DSP2.219 (219_GND), DSP2.220 (GND_220), DSP3.7 (7_GND), DSP3.8 (GND_8), DSP3.9 (9_GND), DSP3.10 (GND10), DSP3.28 (GP27_28), ECAP1.6, ECAP2.6, I2C1.3, I2C1.4, I2C1.9, I2C1.10, I2C2.3, I2C2.4, I2C2.9, I2C2.10, IPM-LEM1.19, IPM-LEM1.20, IPM-LEM2.19, IPM-LEM2.20, IPM-LEM3.19, IPM-LEM3.20, IPM-LEM4.19, IPM-LEM4.20, J1.9, J2.9, J3.9, J4.9, N1.11, POWER1.15, POWER1.16, POWER1.17, POWER1.18, Q1.2 (E), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R14.2, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R29.2, R31.1, R40.1, R41.1, R50.1, R51.1, R117.2, R119.2, R121.2, RU1.1, RU7.2, RU8.2, RU9.2, RU10.2, RU11.2, RU12.2, RU13.2, RU14.2, RU15.2, RU16.2, RU17.2, RU18.2, SPI1.5, SPI1.6, SPI2.5, SPI2.6, SPI-DAC1.5, SPI-DAC1.6, SPI-DAC1.7, SPI-DAC1.8, TESTPOINT3.1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
AVDD: D2.2, D3.2, D4.2, D5.2, POWER1.28
D12V1: CAN_A1.1, CAN_B1.1, IPM-LEM1.14, IPM-LEM1.16, IPM-LEM2.14, IPM-LEM2.16, IPM-LEM3.14, IPM-LEM3.16, IPM-LEM4.14, IPM-LEM4.16, POWER1.19, POWER1.20
D+5V: C3.1, C4.1, C8.1, C9.1, CAN_A1.2, CAN_B1.2, D1.1 (A), DSP1.81 (81+5V), DSP1.82 (+5V_82), DSP3.1 (1_+5V), DSP3.2 (+5V_2), DSP3.3 (3_+5V), DSP3.4 (+5V_4), DSP3.5 (5_+5V), DSP3.6 (+5V_6), J1.10, J2.10, J3.10, J4.10, POWER1.29, POWER1.30, R30.2, SPI1.3, SPI1.4, SPI2.7, SPI2.8, SPI-DAC1.13, SPI-DAC1.14, U1.20 (VCC), U2.20 (VCC), U3.20 (VCC), U4.20 (VCC), UART1.1, UART2.1, UART3.1, UART4.1
unnamed: A1.3 (+IN), C24.1, R56.2, R57.2
unnamed: A1.4 (-IN), R58.2, R59.2
unnamed: A1.1 (out), R59.1, R68.2
unnamed: A2.3 (+IN), C26.1, R60.2, R61.2
unnamed: A2.4 (-IN), R62.2, R63.2
unnamed: A2.1 (out), R63.1, R69.2
unnamed: A3.3 (+IN), C27.1, R64.2, R65.2
unnamed: A3.4 (-IN), R66.2, R67.2
unnamed: A3.1 (out), R67.1, R70.2
unnamed: A4.3 (+IN), C45.1, R71.2, R72.2
unnamed: A4.4 (-IN), R73.2, R74.2
unnamed: A4.1 (out), R74.1, R83.2
unnamed: A5.3 (+IN), C46.1, R75.2, R76.2
unnamed: A5.4 (-IN), R77.2, R78.2
unnamed: A5.1 (out), R78.1, R84.2
unnamed: A6.3 (+IN), C47.1, R79.2, R80.2
unnamed: A6.4 (-IN), R81.2, R82.2
unnamed: A6.1 (out), R82.1, R85.2
unnamed: A7.3 (+IN), C63.1, R86.2, R87.2
unnamed: A7.4 (-IN), R88.2, R89.2
unnamed: A7.1 (out), R89.1, R98.2
unnamed: A8.3 (+IN), C64.1, R90.2, R91.2
unnamed: A8.4 (-IN), R92.2, R93.2
unnamed: A8.1 (out), R93.1, R99.2
unnamed: A9.3 (+IN), C65.1, R94.2, R95.2
unnamed: A9.4 (-IN), R96.2, R97.2
unnamed: A9.1 (out), R97.1, R100.2
unnamed: A10.3 (+IN), C81.1, R101.2, R102.2
unnamed: A10.4 (-IN), R103.2, R104.2
unnamed: A10.1 (out), R104.1, R113.2
unnamed: A11.3 (+IN), C82.1, R105.2, R106.2
unnamed: A11.4 (-IN), R107.2, R108.2
unnamed: A11.1 (out), R108.1, R114.2
unnamed: A12.3 (+IN), C83.1, R109.2, R110.2
unnamed: A12.4 (-IN), R111.2, R112.2
unnamed: A12.1 (out), R112.1, R115.2
unnamed: C10.2, N1.3, R37.1, R40.2
unnamed: C11.2, N1.5, R39.1, R41.2
unnamed: C12.1, N1.2, R36.1, R42.1
unnamed: C12.2, N1.1, R42.2, R44.1
unnamed: C13.1, N1.6, R38.1, R43.1
unnamed: C13.2, N1.7, R43.2, R45.1
unnamed: C17.2, DC_BUS_2M3.1, N1.10, R46.1, R50.2
unnamed: C18.2, DC_BUS_2M4.1, N1.12, R48.1, R51.2
unnamed: C19.1, GND_2M3.1, N1.9, R47.1, R52.1
unnamed: C19.2, N1.8, R52.2, R54.1
unnamed: C20.1, GND_2M4.1, N1.13, R49.1, R53.1
unnamed: C20.2, N1.14, R53.2, R55.1
unnamed: D1.2 (K), R15.2
unnamed: DI1.3, DI1.4, R28.2
unnamed: DI2.3, DI2.4, R116.2
unnamed: DI3.3, DI3.4, R118.2
unnamed: DI4.3, DI4.4, R120.2
unnamed: Q1.1 (B), R13.1, R14.1
unnamed: Q1.3 (C), R15.1
unnamed: R56.1, RB1.2, RU7.1
unnamed: R60.1, RB2.2, RU8.1
unnamed: R64.1, RB3.2, RU9.1
unnamed: R71.1, RB4.2, RU10.1
unnamed: R75.1, RB5.2, RU11.1
unnamed: R79.1, RB6.2, RU12.1
unnamed: R86.1, RB7.2, RU13.1
unnamed: R90.1, RB8.2, RU14.1
unnamed: R94.1, RB9.2, RU15.1
unnamed: R101.1, RB10.2, RU16.1
unnamed: R105.1, RB11.2, RU17.1
unnamed: R109.1, RB12.2, RU18.1
unnamed: RU2.2, SPI-DAC1.19, SPI-DAC1.20
PE_GND: J1.7, J2.7, J3.7, J4.7, SPI-DAC1.15, SPI-DAC1.16, SPI-DAC1.17, SPI-DAC1.18
REF_3V: C36.2, C42.1, RB1.1, RB2.1, RB3.1, RB4.1, RB5.1, RB6.1, RB7.1, RB8.1, RB9.1, RB10.1, RB11.1, RB12.1, RU2.1, U5.6 (VOUT)
VDD: DI1.1, DI2.1, DI3.1, DI4.1, ECAP1.5, ECAP2.5, I2C1.1, I2C1.2, I2C2.1, I2C2.2, J1.8, J2.8, J3.8, J4.8, POWER1.27, R32.2, R33.2, R34.1, R35.1, UART1.2, UART2.2, UART3.2, UART4.2
